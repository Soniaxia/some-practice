# Keil uVision project comprehensive.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: comprehensive +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include\drivers;..\include\app;..\include\gui;..\net\eth;..\net\USIP
  group src
    ./: main.c
  group app
    ../app/: temperature.c radio.c
  group drivers
    ../c_lib/: lcd9325.c spi.c touch.c iic.c tmp75.c rda5807.c
  group gui
    ../gui/: button.c gui.c
  group resource
    ../resource/: tmp.c net.c zuo.c you.c
